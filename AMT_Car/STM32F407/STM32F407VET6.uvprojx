# Keil uVision project STM32F407VET6.uvprojx, settings and files
target STM32F407VET6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Libraries;.\Libraries\CMSIS\Include;.\Libraries\src;.\USER;.\Hardware;.\Libraries\inc;.\Hardware\Motor;.\USER\Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./USER/: main.c delay.c init.c
  group Control
    ./Hardware/Motor/: MotorController.c
    ./USER/Control/: PID.c CarController.c
  group Driver
    ./Hardware/: KeyLed.c BTModule.c
    ./Hardware/Motor/: MotorDriver.c Encoder.c
  group CMSIS
    ./Libraries/src/: stm32f4xx_it.c system_stm32f4xx.c
    ./Libraries/inc/: stm32f4xx_conf.h stm32f4xx.h
    ./Libraries/: startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ./Libraries/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c
